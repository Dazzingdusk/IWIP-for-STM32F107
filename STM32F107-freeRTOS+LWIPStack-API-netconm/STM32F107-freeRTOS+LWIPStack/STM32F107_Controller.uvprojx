# Keil uVision project STM32F107_Controller.uvprojx, settings and files
target FreeRTOS+LWIP (ARM-ADS)
  device: STM32F107RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F107_LWIPStatck +hex
  AfterMake: fromelf.exe --bin -o .\bin\@L.bin .\project\object\@L.axf
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c include: .\FreeRTOS\include;.\lib\CMSIS\CM3\CoreSupport\MDK;.\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\lib\STM32F10x_StdPeriph_Driver\inc;.\lib\STM32_ETH_Driver\inc;.\user;.\lwip-2.0.3\src\include;.\lwip-2.0.3\src\include\lwip;.\lwip-2.0.3\src\include\netif;.\lwip-2.0.3\arch;.\lwip-2.0.3;.\Drv;.\lwip-2.0.3\src\include\lwip\priv;.\lwip-2.0.3\src\include\lwip;.\user\tcp_server_demo;.\user\tcpecho
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./user/: main.c stm32f10x_it.c
  group DRV
    ./Drv/: drv_ethernet.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c heap_2.c list.c port.c queue.c tasks.c timers.c
  group STM32F10x
    ./lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ./lib/STM32_ETH_Driver/src/: stm32_eth.c
  group CMSIS
    ./lib/CMSIS/CM3/CoreSupport/MDK/: core_cm3.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group LWIP_APP
    ./user/: tcpecho_raw.c
    ./user/tcp_server_demo/: tcp_server_demo.c
    ./user/tcpecho/: tcpecho.c
  group LWIP_NETIF
    ./lwip-2.0.3/src/netif/: ethernet.c ethernetif.c
  group LWIP_CORE
    ./lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ./lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LWIP_ARCH
    ./lwip-2.0.3/arch/: sys_arch.c
  group LWIP_API
    ./lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
software components: CMSIS:CORE 4.3.0
